B::
v precond.is_norm_vol=1

ENDDO