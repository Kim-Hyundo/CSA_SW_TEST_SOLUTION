B::

print "dummy program"

ENDDO